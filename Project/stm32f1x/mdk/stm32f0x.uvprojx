# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F103xB USE_FULL_LL_DRIVER
  c include: ..\..\..\mcu\mculib\stm32f1\CMSIS\Include;..\..\..\mcu\mculib\stm32f1\STM32F1xx_HAL_Driver\Inc;..\..\..\mcu\mculib\stm32f1\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\mcu\stm32f0x\ebox;..\..\..\mcu\stm32f0x\ebox\core;..\..\..\mcu\stm32f0x\ebox\Peripherals;..\..\..\common\util;..\..\..\common\edriver;..\..\..\common\network;..\..\..\common\fat;..\..\..\user;..\..\..\common\util\printf;..\..\..\mcu\mculib\stm32f1\ebox;..\..\..\common\edriver\F0;..\..\..\..\my-lib\drive\ebox;..\..\..\common\edriver\F0\WiFi
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../mcu/mculib/stm32f1/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group start_code
    ../../../mcu/mculib/stm32f1/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f100xb.s startup_stm32f100xe.s startup_stm32f101x6.s startup_stm32f101xb.s startup_stm32f101xe.s startup_stm32f101xg.s startup_stm32f102x6.s startup_stm32f102xb.s startup_stm32f103x6.s startup_stm32f103xb.s startup_stm32f103xe.s startup_stm32f103xg.s startup_stm32f105xc.s startup_stm32f107xc.s
  group libraries_LL
    ../../../mcu/mculib/stm32f1/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group libraries_HAL
    ../../../mcu/mculib/stm32f1/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
  group ebox
    ../../../mcu/stm32f0x/ebox/Peripherals/: ebox_gpio.cpp ebox_analog.cpp ebox_uart.cpp ebox_tim.cpp ebox_spi.cpp ebox_i2c.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_rtc.cpp ebox_exti.cpp
    ../../../mcu/stm32f0x/ebox/core/: ebox_core.cpp
    ../../../mcu/mculib/stm32f1/ebox/: stm32_define.h target_mcu.h
  group user
    ../../../user/: main.cpp
    ../../../User/: ebox_config.h ebox_it.cpp
  group util
    ../../../common/util/: printf.cpp ebox_mem.c
  group example
    ../../../example/: I2C_search address.cpp core_cpuClock.cpp core_Systick.cpp gpio_exti.cpp gpio_readWrite.cpp mem_test.cpp tim_timer.cpp usart.cpp usart_polling.cpp iflash.cpp rtc_calendar F0.cpp iwdg.cpp analog_read--F0.cpp analog_DMA.cpp tim_pwm.cpp tim_capture.cpp power_sleep.cpp power_rtc wakeup.cpp
