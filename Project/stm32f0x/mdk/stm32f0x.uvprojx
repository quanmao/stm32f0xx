# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F072xB USE_FULL_LL_DRIVER
  c include: ..\..\..\mcu\stm32f0x\Libraries\CMSIS\Include;..\..\..\mcu\stm32f0x\Libraries\STM32F0xx_HAL_Driver\Inc;..\..\..\mcu\stm32f0x\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\mcu\stm32f0x\ebox;..\..\..\mcu\stm32f0x\ebox\core;..\..\..\mcu\stm32f0x\ebox\Peripherals;..\..\..\common\util;..\..\..\common\edriver;..\..\..\common\network;..\..\..\common\fat;..\..\..\user;..\..\..\common\util\printf;..\..\..\mcu\stm32f0x\ebox\mcu;..\..\..\common\edriver\F0;..\..\..\..\my-lib\drive\ebox;..\..\..\common\edriver\F0\WiFi
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../mcu/stm32f0x/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group start_code
    ../../../mcu/stm32f0x/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030xc.s startup_stm32f030x6.s startup_stm32f030x8.s startup_stm32f031x6.s startup_stm32f038xx.s startup_stm32f042x6.s startup_stm32f048xx.s startup_stm32f051x8.s startup_stm32f058xx.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f071xb.s startup_stm32f072xb.s startup_stm32f078xx.s startup_stm32f091xc.s startup_stm32f098xx.s
  group libraries_LL
    ../../../mcu/stm32f0x/Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_utils.c stm32f0xx_ll_rcc.c stm32f0xx_ll_i2c.c stm32f0xx_ll_adc.c stm32f0xx_ll_rtc.c
  group libraries_HAL
    ../../../mcu/stm32f0x/Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group ebox
    ../../../mcu/stm32f0x/ebox/Peripherals/: ebox_gpio.cpp ebox_analog.cpp ebox_uart.cpp ebox_tim.cpp ebox_spi.cpp ebox_i2c.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_rtc.cpp ebox_exti.cpp
    ../../../mcu/stm32f0x/ebox/core/: ebox_core.cpp
  group user
    ../../../user/: main.cpp
    ../../../User/: ebox_config.h ebox_it.cpp
  group util
    ../../../common/util/: printf.cpp ebox_mem.c
  group example
    ../../../example/: I2C_search address.cpp core_cpuClock.cpp core_Systick.cpp gpio_exti.cpp gpio_readWrite.cpp mem_test.cpp tim_timer.cpp usart.cpp usart_polling.cpp iflash.cpp rtc_calendar F0.cpp
